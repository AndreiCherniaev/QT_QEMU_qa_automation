## my_external_tree/Config.in
```kconfig
source "/home/a/Downloads/myGitHub/QT_QEMU_qa_automation/my_external_tree/package/smilebrd_serv/Config.in"
```
